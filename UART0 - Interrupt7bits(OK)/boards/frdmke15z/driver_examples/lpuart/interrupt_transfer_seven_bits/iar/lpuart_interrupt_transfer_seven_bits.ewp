# IAR project lpuart_interrupt_transfer_seven_bits.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE15Z256xxx7 NXP MKE15Z256xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKE15Z256VLL7; FRDM_KE15Z; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MKE15Z7/drivers; ../../../../../../devices/MKE15Z7/drivers; ../../../../../../devices/MKE15Z7/drivers; ../../../../../../devices/MKE15Z7/drivers; ../../../../../../devices/MKE15Z7/drivers; ../../../../../../devices/MKE15Z7; ../../../../../../devices/MKE15Z7/utilities/str; ../../../../../../devices/MKE15Z7/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../components/serial_manager; ../../../../../../devices/MKE15Z7/drivers; ../../../../../../devices/MKE15Z7/drivers; ../../../../../../devices/MKE15Z7/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: lpuart_interrupt_transfer_seven_bits.out
  ILINK.IlinkIcfFile: MKE15Z256xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKE15Z256VLL7; FRDM_KE15Z; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0plus.h mpu_armv7.h mpu_armv8.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/uart
    ../../../../../../components/uart/: lpuart_adapter.c uart.h
  group device
    ../../../../../../devices/MKE15Z7/: fsl_device_registers.h MKE15Z7.h MKE15Z7_features.h system_MKE15Z7.c system_MKE15Z7.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MKE15Z7/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h
  group source
    ../: interrupt_transfer_seven_bits.c
  group startup
    ../../../../../../devices/MKE15Z7/iar/: startup_MKE15Z7.s
  group Test_Lib
    ../: cool.c
  group utilities
    ../../../../../../devices/MKE15Z7/utilities/: fsl_assert.c
    ../../../../../../devices/MKE15Z7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MKE15Z7/utilities/str/: fsl_str.c fsl_str.h
